# Keil uVision project STM32-DEMO.uvprojx, settings and files
target USART1-DEMO (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-DEMO +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, ECOBIN_UART_VOLATILE_CONFIG_HIL
  c include: ..\CMSIS;..\FWlib\inc;..\USER;.\uar
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c usart1.c led.c adc.c usart3.c
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_adc.c stm32f10x_tim.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
